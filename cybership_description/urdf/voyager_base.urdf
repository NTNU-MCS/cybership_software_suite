Commit message: feat: add urdf

File: cybership_description/urdf/voyager_base.urdf (robot description, URDF)
Before this commit: robot cybership_voyager, 3 links, 2 joints
Joints:
- joint imu_joint: origin xyz=0.4 0 0.1 rpy=0 0 0 -> xyz=-0.1 0 0.1 rpy=0 0 0
